# IAR project robot_line_tracer_v3.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RB ST STM32F103RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; __CORTEXM3__
  ICCARM.CCIncludePath2: C:\Users\kdm79\Desktop\cortex-M3_test\Demo\robot_line_tracer_v3\app\inc; C:\Users\kdm79\Desktop\cortex-M3_test\Demo\robot_line_tracer_v3\stm32f10x_lib\inc; C:\Users\kdm79\Desktop\cortex-M3_test\Demo\robot_line_tracer_v3\dynamixel_sdk\include\dynamixel_sdk
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: robot_line_tracer_v3.srec
  ILINK.IlinkOutputFile: robot_line_tracer_v3.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app/inc
    app/inc/: circle_queue.h debug.h dynamixel_to_uart.h exti.h key.h led.h llio.h my_timer.h sensor.h stm32f10x_conf.h stm32f10x_it.h system_stm32f10x.h systick.h wifi_to_uart.h
  group app/src
    app/src/: circle_queue.c debug.c dynamixel_to_uart.c exti.c key.c led.c llio.c main.c my_timer.c sensor.c startup_stm32f10x_md.s stm32f10x_it.c system_stm32f10x.c systick.c wifi_to_uart.c
  group dynamixel_sdk/inc
    dynamixel_sdk/include/dynamixel_sdk/: dynamixel_sdk.h group_bulk_read.h group_bulk_write.h group_sync_read.h group_sync_write.h packet_handler.h port_handler.h port_handler_arduino.h port_handler_cortex_m3.h port_handler_linux.h port_handler_mac.h port_handler_windows.h protocol1_packet_handler.h protocol2_packet_handler.h robotis_def.h
  group dynamixel_sdk/src
    dynamixel_sdk/src/dynamixel_sdk/: group_bulk_read.c group_bulk_write.c group_sync_read.c group_sync_write.c packet_handler.c port_handler.c port_handler_arduino.cpp port_handler_cortex_m3.c port_handler_linux.c port_handler_mac.c port_handler_windows.c protocol1_packet_handler.c protocol2_packet_handler.c
  group stm32f10x_lib/inc
    stm32f10x_lib/inc/: core_cm3.h core_cmFunc.h core_cmInstr.h misc.h stm32f10x.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group stm32f10x_lib/src
    stm32f10x_lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
